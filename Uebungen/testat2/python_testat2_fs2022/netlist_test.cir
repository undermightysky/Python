R1 1 2 1
R2 2 0 2
R3 2 3 3
Iq 0 1 DC 50e-3
Vcc 3 0 DC 230
